**************************************************
* Manufacturer:           Würth Elektronik
* Kinds:                  SMT Common Mode Line Filter
* Matchcode:              WE-CNSW
* Library Type:           LTspice
* Version:                rev25b
* Created/modified by:    Ella
* Date and Time:          2025-06-18
* Team:                   eiSos EDA Service
* Contact:                libraries@we-online.com
**************************************************
* Copyright(C) 2025 Würth Elektronik eiSos GmbH & Co. KG
* All Rights Reserved.
**************************************************
* Disclaimer: While Würth Elektronik eiSos has made every reasonable effort to ensure the accuracy
* of the simulation models provided, Würth Elektronik eiSos does not guarantee the exemption of error on
* the simulation models, nor does Würth Elektronik eiSos guarantee that the simulation model is current.
* Würth Elektronik eiSos reserves the right to make any adjustments at any time without notice.
* Würth Elektronik eiSos expressly disclaims all implied warranties regarding this simulation model.
**************************************************
.subckt 0603_744230121_120ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  DL3=3.21356440083719E-10
+  DC3=8.12514784156175E-10
+  DR3=121.365600810607
+  DR4=67.9989469136311
+  Rdc=0.175
+  ck=1.8pF
+  L1=1.03776366835462E-07
+  L2=2.85677171523081E-07
+  L3=1.00000000901773E-09
+  L4=3.79555466759053E-08
+  C1=2.60105208926701E-16
+  RS1=6.19761662005791
+  RS2=260.853288265391
+  RS3=237.589274315202
+  RS4=714.407442512723
+  R2=0.177252883973335
.ends 0603_744230121_120ohm
*****
.subckt 0603_744230181_180ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  DL3=3.0267438167563E-10
+  DC3=3.33831866585721E-11
+  DR3=832.258524528865
+  DR4=456.856178522626
+  Rdc=0.2
+  ck=2.64p
+  L1=1.51800159040882E-08
+  L2=4.31019180860367E-07
+  L3=8.07362821331113E-08
+  L4=5.08654968567098E-08
+  C1=2.3275544138354E-14
+  RS1=292.605026922307
+  RS2=309.909870040185
+  RS3=181.488732454158
+  RS4=994.310575635818
+  R2=458.908496550785
.ends 0603_744230181_180ohm
*****
.subckt 0603_744230220_22ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  DL3=0.00000000019
+  DC3=0.00000000012
+  DR3=124.9
+  DR4=71.7
+  Rdc=0.2
+  ck=2.64p
+  L1=5.34317340558565E-09
+  L2=8.60115622182272E-08
+  L3=1.00000000000001E-14
+  L4=4.14464958795088E-09
+  C1=2.6021588829417E-15
+  RS1=227.07018435115
+  RS2=44.1045008464177
+  RS3=142.794989197713
+  RS4=171.457886084178
+  R2=21.6590097709174
.ends 0603_744230220_22ohm
*****
.subckt 0603_744230251_250ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=1.78130283754455E-08
+  L2=7.56550033933199E-07
+  L3=1.51732881489898E-08
+  L4=9.25299457255913E-09
+  C1=8.69848087139472E-14
+  RS1=6834.45776655021
+  RS2=669.173532792915
+  RS3=5737.4458234728
+  RS4=1483.23981576039
+  R2=0.69290914169179
+  DL3=3.09086132419024E-10
+  DC3=7.51847021856422E-12
+  DR3=158.699703923207
+  DR4=180.832117119793
+  Rdc=0.31
+  ck=4.77436431106064E-12
.ends 0603_744230251_250ohm
*****
.subckt 0603_744230450_45ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  DL3=2.30743523631809E-10
+  DC3=1.87201966401594E-09
+  DR3=114.9307793754
+  DR4=55.8672000989
+  Rdc=0.1
+  ck=.93p
+  L1=8.06194410104808E-08
+  L2=7.22820473671359E-08
+  L3=9.59758487690461E-10
+  L4=1.24033958470548E-08
+  C1=1.29346472503743E-16
+  RS1=80.9681291684029
+  RS2=18.4208412943615
+  RS3=70.5917411257508
+  RS4=222.475102366592
+  R2=6.10531126153076
.ends 0603_744230450_45ohm
*****
.subckt 0603_744230900_90ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  DL3=0.00000000028
+  DC3=0.0000000012
+  DR3=1124.9
+  DR4=131.7
+  Rdc=0.13
+  ck=1.68p
+  L1=2.17726723091073E-07
+  L2=6.25188018150591E-09
+  L3=2.57400654656263E-08
+  L4=6.68329302271038E-09
+  C1=4.26112117561339E-16
+  RS1=171.9721829612
+  RS2=18.7206073606971
+  RS3=528.705436547341
+  RS4=1577.90540608866
+  R2=2.63697832467138
.ends 0603_744230900_90ohm
*****
.subckt 0805_744231061_67ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=88.51n
+  L2=62.49n
+  L3=19.28n
+  L4=48.40n
+  C1=15.24p
+  RS1=136.59
+  RS2=10
+  RS3=819.22
+  RS4=3492.3
+  R2=498.02
+  dL3=302.14p
+  dC3=6.17p
+  DR3=640.51
+  DR4=37.32
+  Rdc=0.14
+  ck=1.3pF
.ends 0805_744231061_67ohm
*****
.subckt 0805_744231061A_67ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=88.51n
+  L2=62.49n
+  L3=19.28n
+  L4=48.40n
+  C1=15.24p
+  RS1=136.59
+  RS2=10
+  RS3=819.22
+  RS4=3492.3
+  R2=498.02
+  dL3=302.14p
+  dC3=6.17p
+  DR3=640.51
+  DR4=37.32
+  Rdc=0.14
+  ck=1.3pF
.ends 0805_744231061A_67ohm
*****
.subckt 0805_744231091_90ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=90.3n
+  L2=34.92n
+  L3=25.56n
+  L4=7.15n
+  C1=0.055p
+  RS1=1086.39
+  RS2=162.52
+  RS3=379.56
+  RS4=409.81
+  R2=324.66
+  dL3=395p
+  dC3=0.1p
+  DR3=168.1
+  DR4=359.47
+  Rdc=0.18
+  ck=2.41p
.ends 0805_744231091_90ohm
*****
.subckt 0805_744231091A_90ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=90.3n
+  L2=34.92n
+  L3=25.56n
+  L4=7.15n
+  C1=0.055p
+  RS1=1086.39
+  RS2=162.52
+  RS3=379.56
+  RS4=409.81
+  R2=324.66
+  dL3=395p
+  dC3=0.1p
+  DR3=168.1
+  DR4=359.47
+  Rdc=0.18
+  ck=2.41p
.ends 0805_744231091A_90ohm
*****
.subckt 0805_744231121_120ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=256.43n
+  L2=186.53n
+  L3=86.19n
+  L4=36.04n
+  C1=0.0529p
+  RS1=170.67
+  RS2=27.78
+  RS3=155.67
+  RS4=693.55
+  R2=35.41
+  dL3=392.5pH
+  dC3=0.01pF
+  DR3=10
+  DR4=50
+  Rdc=0.185
+  ck=1.99pF
.ends 0805_744231121_120ohm
*****
.subckt 0805_744231121A_120ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=256.43n
+  L2=186.53n
+  L3=86.19n
+  L4=36.04n
+  C1=0.0529p
+  RS1=170.67
+  RS2=27.78
+  RS3=155.67
+  RS4=693.55
+  R2=35.41
+  dL3=392.5pH
+  dC3=0.01pF
+  DR3=10
+  DR4=50
+  Rdc=0.185
+  ck=1.99pF
.ends 0805_744231121A_120ohm
*****
.subckt 0805_744231181_180ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=263.22n
+  L2=91.45n
+  L3=22.74n
+  L4=33.31n
+  C1=0.009p
+  RS1=273.32
+  RS2=348.57
+  RS3=421.97
+  RS4=506.83
+  R2=20.07
+  dL3=411.67p
+  dC3=17.92p
+  DR3=232.39
+  DR4=528.2
+  Rdc=0.22
+  ck=2.33p
.ends 0805_744231181_180ohm
*****
.subckt 0805_744231181A_180ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=263.22n
+  L2=91.45n
+  L3=22.74n
+  L4=33.31n
+  C1=0.009p
+  RS1=273.32
+  RS2=348.57
+  RS3=421.97
+  RS4=506.83
+  R2=20.07
+  dL3=411.67p
+  dC3=17.92p
+  DR3=232.39
+  DR4=528.2
+  Rdc=0.22
+  ck=2.33p
.ends 0805_744231181A_180ohm
*****
.subckt 0805_744231261_260ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=469.75n
+  L2=199.99n
+  L3=138.06n
+  L4=32.17n
+  C1=0.014p
+  RS1=264.12
+  RS2=478.71
+  RS3=478.71
+  RS4=478.71
+  R2=12.92
+  dL3=874p
+  dC3=0.011p
+  DR3=1
+  DR4=288
+  Rdc=0.28
+  ck=2p
.ends 0805_744231261_260ohm
*****
.subckt 0805_744231261A_260ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=469.75n
+  L2=199.99n
+  L3=138.06n
+  L4=32.17n
+  C1=0.014p
+  RS1=264.12
+  RS2=478.71
+  RS3=478.71
+  RS4=478.71
+  R2=12.92
+  dL3=874p
+  dC3=0.011p
+  DR3=1
+  DR4=288
+  Rdc=0.28
+  ck=2p
.ends 0805_744231261A_260ohm
*****
.subckt 0805_744231371_370ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=813.59n
+  L2=258.61n
+  L3=120.61n
+  L4=59.28n
+  C1=0.034p
+  RS1=360.86
+  RS2=589.54
+  RS3=589.54
+  RS4=601.39
+  R2=13.96
+  dL3=0.6n
+  dC3=0.07p
+  DR3=10
+  DR4=118
+  Rdc=0.38
+  ck=3.91p
.ends 0805_744231371_370ohm
*****
.subckt 0805_744231371A_370ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=813.59n
+  L2=258.61n
+  L3=120.61n
+  L4=59.28n
+  C1=0.034p
+  RS1=360.86
+  RS2=589.54
+  RS3=589.54
+  RS4=601.39
+  R2=13.96
+  dL3=0.6n
+  dC3=0.07p
+  DR3=10
+  DR4=118
+  Rdc=0.38
+  ck=3.91p
.ends 0805_744231371A_370ohm
*****
.subckt 1206_744232090_90ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=404.99n
+  L2=14.03n
+  L3=20.64n
+  L4=0.61n
+  C1=0.136p
+  RS1=196.36
+  RS2=71.04
+  RS3=2245.23
+  RS4=2245.23
+  R2=197.59
+  dL3=0.5n
+  dC3=0.07p
+  DR3=10
+  DR4=78
+  Rdc=0.16
+  ck=1.71p
.ends 1206_744232090_90ohm
*****
.subckt 1206_744232090A_90ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=404.99n
+  L2=14.03n
+  L3=20.64n
+  L4=0.61n
+  C1=0.136p
+  RS1=196.36
+  RS2=71.04
+  RS3=2245.23
+  RS4=2245.23
+  R2=197.59
+  dL3=0.5n
+  dC3=0.07p
+  DR3=10
+  DR4=78
+  Rdc=0.16
+  ck=1.71p
.ends 1206_744232090A_90ohm
*****
.subckt 1206_744232102_1000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=1.64u
+  L2=64.03n
+  L3=347.3n
+  L4=133.04n
+  C1=0.1p
+  RS1=1575.61
+  RS2=1046.84
+  RS3=1462.2
+  RS4=1046.84
+  R2=14.07
+  dL3=977.65p
+  dC3=7.91p
+  DR3=309.77
+  DR4=138.01
+  Rdc=0.45
+  ck=9.32p
.ends 1206_744232102_1000ohm
*****
.subckt 1206_744232102A_1000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=1.64u
+  L2=64.03n
+  L3=347.3n
+  L4=133.04n
+  C1=0.1p
+  RS1=1575.61
+  RS2=1046.84
+  RS3=1462.2
+  RS4=1046.84
+  R2=14.07
+  dL3=977.65p
+  dC3=7.91p
+  DR3=309.77
+  DR4=138.01
+  Rdc=0.45
+  ck=9.32p
.ends 1206_744232102A_1000ohm
*****
.subckt 1206_744232161_160ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=358.5n
+  L2=140.9n
+  L3=40.57n
+  L4=27.43n
+  C1=0.03p
+  RS1=165.67
+  RS2=246.51
+  RS3=931.87
+  RS4=106.2
+  R2=172.41
+  dL3=500p
+  dC3=0.001p
+  DR3=1436.81
+  DR4=1178.6
+  Rdc=0.21
+  ck=2.34p
.ends 1206_744232161_160ohm
*****
.subckt 1206_744232161A_160ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=358.5n
+  L2=140.9n
+  L3=40.57n
+  L4=27.43n
+  C1=0.03p
+  RS1=165.67
+  RS2=246.51
+  RS3=931.87
+  RS4=106.2
+  R2=172.41
+  dL3=500p
+  dC3=0.001p
+  DR3=1436.81
+  DR4=1178.6
+  Rdc=0.21
+  ck=2.34p
.ends 1206_744232161A_160ohm
*****
.subckt 1206_744232222_2200ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=3.1u
+  L2=456.9n
+  L3=794.49n
+  L4=530.88n
+  C1=0.08p
+  RS1=2061.24
+  RS2=2061.24
+  RS3=1662.57
+  RS4=1702.13
+  R2=10.88
+  dL3=1.2n
+  dC3=2.5p
+  DR3=10
+  DR4=95
+  Rdc=0.7
+  ck=14.34p
.ends 1206_744232222_2200ohm
*****
.subckt 1206_744232222A_2200ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=3.1u
+  L2=456.9n
+  L3=794.49n
+  L4=530.88n
+  C1=0.08p
+  RS1=2061.24
+  RS2=2061.24
+  RS3=1662.57
+  RS4=1702.13
+  R2=10.88
+  dL3=1.2n
+  dC3=2.5p
+  DR3=10
+  DR4=95
+  Rdc=0.7
+  ck=14.34p
.ends 1206_744232222A_2200ohm
*****
.subckt 1206_744232222M_2200ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=3.1u
+  L2=456.9n
+  L3=794.49n
+  L4=530.88n
+  C1=0.08p
+  RS1=2061.24
+  RS2=2061.24
+  RS3=1662.57
+  RS4=1702.13
+  R2=10.88
+  dL3=1.2n
+  dC3=2.5p
+  DR3=10
+  DR4=95
+  Rdc=0.7
+  ck=14.34p
.ends 1206_744232222M_2200ohm
*****
.subckt 1206_744232261_260ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=69.88n
+  L2=938.9n
+  L3=32.32n
+  L4=13.33n
+  C1=0.06p
+  RS1=423.22
+  RS2=537.78
+  RS3=651.87
+  RS4=992.88
+  R2=45.99
+  dL3=740.8p
+  dC3=0.1p
+  DR3=400
+  DR4=200
+  Rdc=0.25
+  ck=3.5p
.ends 1206_744232261_260ohm
*****
.subckt 1206_744232261A_260ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=69.88n
+  L2=938.9n
+  L3=32.32n
+  L4=13.33n
+  C1=0.06p
+  RS1=423.22
+  RS2=537.78
+  RS3=651.87
+  RS4=992.88
+  R2=45.99
+  dL3=740.8p
+  dC3=0.1p
+  DR3=400
+  DR4=200
+  Rdc=0.25
+  ck=3.5p
.ends 1206_744232261A_260ohm
*****
.subckt 1206_744232601_600ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=980.39n
+  L2=1u
+  L3=148.04n
+  L4=30.78n
+  C1=0.09p
+  RS1=1404.92
+  RS2=222.94
+  RS3=3552.29
+  RS4=1249.35
+  R2=2.65
+  dL3=872.39p
+  dC3=0.869p
+  DR3=81.43
+  DR4=227
+  Rdc=0.41
+  ck=5.48p
.ends 1206_744232601_600ohm
*****
.subckt 1206_744232601A_600ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=980.39n
+  L2=1u
+  L3=148.04n
+  L4=30.78n
+  C1=0.09p
+  RS1=1404.92
+  RS2=222.94
+  RS3=3552.29
+  RS4=1249.35
+  R2=2.65
+  dL3=872.39p
+  dC3=0.869p
+  DR3=81.43
+  DR4=227
+  Rdc=0.41
+  ck=5.48p
.ends 1206_744232601A_600ohm
*****
.subckt 1812_744235101_8000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=0.0000797330260317076
+  L2=9.88094162242991E-06
+  L3=1.44068328704984E-06
+  L4=9.85148481422561E-08
+  C1=1.3645243390331E-13
+  RS1=27155.0098359823
+  RS2=19801.2021163916
+  RS3=3707.15015579865
+  RS4=4502.76026046935
+  R2=0.805434695527514
+  DL3=0.00000001
+  DC3=0.0000000000076
+  DR3=436.759904482883
+  DR4=390.738116581923
+  Rdc=1.30857872175911
+  ck=1.98982670454923E-11
.ends 1812_744235101_8000ohm
*****
.subckt 1812_744235110_5000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=8.85047647829296E-06
+  L2=0.0000034430683879953
+  L3=3.38096411330201E-08
+  L4=1.00652585896406E-08
+  C1=1.31229796204887E-13
+  RS1=7427.18723080165
+  RS2=1810.64222257634
+  RS3=34746.6565929217
+  RS4=3695.42782092552
+  R2=216.5
+  DL3=2.01815820812556E-09
+  DC3=3.07079198420314E-12
+  DR3=155.69656586632
+  DR4=156.010213182894
+  Rdc=0.501580452433977
+  ck=2.0478163676467E-11
.ends 1812_744235110_5000ohm
*****
.subckt 1812_744235220_8000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=0.0000125216320217548
+  L2=6.54898754606424E-06
+  L3=3.16988794176413E-08
+  L4=5.77278199506278E-08
+  C1=1.25221813175292E-13
+  RS1=12209.6414311128
+  RS2=5886.4259377264
+  RS3=35052
+  RS4=1895.91901883094
+  R2=216.065118673868
+  DL3=3.21815820812556E-09
+  DC3=3.07079198420314E-12
+  DR3=155.69656586632
+  DR4=206.010213182894
+  Rdc=1.25158045243397
+  ck=2.0478163676467E-11
.ends 1812_744235220_8000ohm
*****
.subckt 1812_744235601_600ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=0.0000008
+  L2=1.00918818391007E-07
+  L3=6.74713187330646E-08
+  L4=9.06669630529321E-09
+  C1=1.25543915842331E-13
+  RS1=1440
+  RS2=746.462802494614
+  RS3=631.277065514465
+  RS4=595.93833408099
+  R2=2.28453043609872
+  DL3=8.71486162216049E-10
+  DC3=7.13861411629978E-13
+  DR3=350.007574955035
+  DR4=216.761640479245
+  Rdc=0.09
+  ck=7.8992687241322E-12
.ends 1812_744235601_600ohm
*****
.subckt 1812_744235801_800ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=7.25497523126998E-08
+  L2=8.69343176099444E-07
+  L3=3.32504748284714E-07
+  L4=4.44200461773326E-09
+  C1=1.30888075079623E-13
+  RS1=222.796562921102
+  RS2=2020.74697055982
+  RS3=836.191552474128
+  RS4=1617.07077919562
+  R2=4.19037398671819
+  DL3=1.29077433972439E-09
+  DC3=9.75947927079038E-14
+  DR3=114.898321630312
+  DR4=133.300124119974
+  Rdc=0.160020622709807
+  ck=1.52131288040157E-11
.ends 1812_744235801_800ohm
*****
.subckt 1812_744235900_90ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=0.000000008
+  L2=1.00087759037915E-07
+  L3=3.54912711744498E-08
+  L4=9.8487642227681E-09
+  C1=1.50590541068679E-14
+  RS1=5366.19028477718
+  RS2=199.551788174208
+  RS3=369.589376742879
+  RS4=606.815261196718
+  R2=1.19063066786614
+  DL3=1.22301162813465E-09
+  DC3=5.49045546039065E-12
+  DR3=463.914430187231
+  DR4=801.208304688174
+  Rdc=0.0742528369720532
+  ck=8.66866041980135E-13
.ends 1812_744235900_90ohm
******************
.subckt 1206_744232101_6000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=100u
+  L2=100n
+  L3=50n
+  L4=20n
+  C1=0.2p
+  RS1=50800
+  RS2=2500
+  RS3=200
+  RS4=200
+  R2=100
+  dL3=15000p
+  dC3=500p
+  DR3=3000
+  DR4=2000
+  Rdc=7
+  ck=9.32p
.ends 1206_744232101_6000ohm
************
.subckt 1812_744235251_10000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=165u
+  L2=100u
+  L3=10u
+  L4=10n
+  C1=0.125p
+  RS1=40000
+  RS2=1300
+  RS3=20000
+  RS4=20000
+  R2=50
+  DL3=8n
+  DC3=8p
+  DR3=250
+  DR4=250
+  Rdc=1.8
+  ck=35p
.ends 1812_744235251_10000ohm
*****
.subckt 1812_744235510_3000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=0.04m
+  L2=0.04m
+  L3=67n
+  L4=9n
+  C1=0.15p
+  RS1=600
+  RS2=27000
+  RS3=40000
+  RS4=10000
+  R2=0.25
+  DL3=6n
+  DC3=13p
+  DR3=365
+  DR4=5000
+  Rdc=0.85
+  ck=25p
.ends 1812_744235510_3000ohm
*****
.subckt 1210_744234101_5500ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=54.4613u
+  L2=9.2707u
+  L3=822.5747n
+  L4=98.4462n
+  C1=76.5065f
+  RS1=28.3896k
+  RS2=19.7934k
+  RS3=3.7071k
+  RS4=4.5028k
+  R2=805.4365m
+  DL3=5.1526n
+  DC3=12.4684p
+  DR3=312.9775
+  DR4=256.7231
+  ck=22.6021p
+  Rdc=3
.ends
*****
.subckt 1210_744234201_10000ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=132.8883u
+  L2=20.7383u
+  L3=823.3701n
+  L4=98.4558n
+  C1=70.0859f
+  RS1=48.4302k
+  RS2=19.8302k
+  RS3=3.7071k
+  RS4=3.7071k
+  R2=805.4365m
+  DL3=5.3994n
+  DC3=16.3865p
+  DR3=311.8793
+  DR4=150.8681
+  ck=34.3735p
+  Rdc=5.5
.ends
*****
.subckt 1210_744234510_2800ohm 1 2 3 4
X1  1  2  3  4  CNSW  PARAMS:
+  L1=19.4868u
+  L2=6.8053u
+  L3=67.3816n
+  L4=9.4443n
+  C1=72.4246f
+  RS1=10.2868k
+  RS2=8.7887k
+  RS3=2.7071k
+  RS4=1.5028k
+  R2=805.4439m
+  DL3=2.6388n
+  DC3=12.4099p
+  DR3=412.6943
+  DR4=306.3945
+  ck=17.1893p
+  Rdc=1.1
.ends
*****
.SUBCKT  CNSW  1  2  3  4  PARAMS:
R_R47  N21893  N21911  {Rs3}
R_R43  N21425  N21441  {Rs2}
R_R4  N22217  N21871  {dR3}
L_L3  N21425  N21441  {L2}
L_L8  N21871  N21893  {L4}
Kn_K1  L_L1  L_L2  1
R_R37  N21241  3  {R2}
R_R48  N21911  N21925  {Rs2}
R_R44  N21441  3  {Rs1}
C_C4  N21871  N22231  {C1}
L_L1  N21441  3  {L1}
C_C1  N21207  N21217  {dC3}
L_L6  N21893  N21911  {L3}
R_R1  1  N21207  {Rdc}
L_L17  N21207  N21585  {dL3}
R_R49  N21925  4  {Rs1}
Kn_K5  L_L17  L_L18
+  L_L19  L_L20  0.9999
R_R3  N21217  N21223  {dR3}
R_R55  N22231  4  {R2}
L_L4  N21911  N21925  {L2}
R_R2  N21207  N21223  {dR4}
L_L19  N21585  N21223  {dL3}
R_R6  2  N21857  {Rdc}
C_C2  N21731  N21585  {ck}
Kn_K4  L_L7  L_L8  1
L_L2  N21925  4  {L1}
R_R41  N21223  N21413  {Rs4}
L_L7  N21223  N21413  {L4}
R_R5  N21857  N21871  {dR4}
L_L18  N21731  N21857  {dL3}
Kn_K3  L_L5  L_L6  1
R_R46  N21871  N21893  {Rs4}
R_R42  N21413  N21425  {Rs3}
L_L5  N21413  N21425  {L3}
C_C9  N21857  N22217  {dC3}
L_L20  N21871  N21731  {dL3}
Kn_K2  L_L3  L_L4  1
C_C3  N21223  N21241  {C1}
.ends  CNSW
*****
